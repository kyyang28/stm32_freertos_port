# Keil uVision project 12a-PORT.uvprojx, settings and files
target STM32F407VG-Discovery (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 12a-PORT
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\src\lib\CMSIS\CM4\CoreSupport;.\src\lib\CMSIS\CM4\DeviceSupport\ST\STM32F4xx;.\src\lib\STM32F4xx_StdPeriph_Drivers\inc;.\src\quad\build;.\src\quad\common;.\src\quad\config;.\src\quad\drivers;.\src\quad\fc;.\src\quad\io;.\src\quad\flight;.\src\quad\sensors;.\src\quad\rx;.\src\quad\io\asyncfatfs;.\src\quad\blackbox;.\src\quad\target\11-RTOS_PORT;.\src\quad\freertos\include;.\src\quad\freertos\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ./src/quad/startup/: startup_stm32f407xx.s
  group STM32F4xx_StdPeriph_Drivers
    ./src/lib/STM32F4xx_StdPeriph_Drivers/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group TARGET
    ./src/quad/target/11-RTOS_PORT/: main.c system_stm32f4xx.c target.c
    ./src/quad/drivers/: system.c
  group DRIVERS
    ./src/quad/drivers/: accgyro_mpu.c accgyro_spi_mpu9250.c bus_spi.c button.c exti.c gps.c gyro_sync.c io.c led.c pwm_output.c rcc.c rx_pwm.c rxSerial1Test.c rxSerial3Test.c rxSerial6Test.c sdcard.c sdcard_standard.c serial.c serial_uart.c serial_uart_stm32f4xx.c timer.c timer_stm32f4xx.c timerLedsTesting.c timerUserBtnInputTesting.c accgyro_i2c_mpu9250.c bitband_i2c_soft.c bus_i2c_soft.c mpu6050_soft_i2c.c mpu9250_soft_i2c.c
  group FC
    ./src/quad/fc/: config.c fc_core.c fc_rc.c fc_tasks.c rc_controls.c runtime_config.c
  group IO
    ./src/quad/io/: beeper.c
    ./src/quad/io/asyncfatfs/: asyncfatfs.c fat_standard.c
  group FLIGHT
    ./src/quad/flight/: mixer.c
  group CONFIG
    ./src/quad/config/: config_eeprom.c feature.c
  group SENSORS
    ./src/quad/sensors/: acceleration.c gyro.c initialisation.c
  group COMMON
    ./src/quad/common/: filter.c maths.c
  group RX
    ./src/quad/rx/: pwm.c rx.c sbus.c
  group BUILD
    ./src/quad/build/: debug.c
  group BLACKBOX
    ./src/quad/blackbox/: blackbox.c blackbox_io.c
  group FREERTOS_CORE
    ./src/quad/freertos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FREERTOS_PORTABLE
    ./src/quad/freertos/portable/MemMang/: heap_4.c
    ./src/quad/freertos/portable/RVDS/ARM_CM4F/: port.c
